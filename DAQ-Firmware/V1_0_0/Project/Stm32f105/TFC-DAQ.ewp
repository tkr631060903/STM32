# IAR project TFC-DAQ.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; ARM_PLATFORM
  ICCARM.CCIncludePath2: ..\..\Include; ..\..\; ..\..\Libraries\CMSIS\Core\CM3; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\Source\DEBUG; ..\..\Source; ..\..\Source\Common; ..\..\Source\Core; ..\..\Source\Driver; ..\..\Source\Driver\USB; ..\..\Source\GUI; ..\..\Source\GUI\GuiMaker; ..\..\Source\GUICore; ..\..\Source\Application; ..\..\Source\Application\QRCode; ..\..\Source\Application\Multi-Media; ..\..\Source\Application\Sensor; ..\..\Source\Application\Communication
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TFC-DAQ.hex
  ILINK.IlinkOutputFile: TFC-DAQ.out
  ILINK.IlinkIcfFile: ..\..\Linker\TFC-DAQ.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: RA8875.out
  group CMSIS
    ../../Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group INC
    ../../Include/: stm32f10x_conf.h stm32f10x_it.h
  group Main
    ../../Source/: main.c UserTask.c
  group Main/Application
    ../../Source/Application/: FsMode.c TFCError.c TFCEvent.c TFCThumb.c
  group Main/Application/Communication
    ../../Source/Application/Communication/: cJSON.c
  group Main/Application/Sensor
    ../../Source/Application/Sensor/: UartSwitch.c
  group Main/Core
    ../../Source/Core/: stm32f10x_it.c
  group Main/DEBUG
    ../../Source/DEBUG/: debug_stm32.c
  group Main/Driver
    ../../Source/Driver/: Beep.c CAN.c GPIO.c InternalFlash.c LedDriver.c OnChipADC.c QuadDAC.C SPIFlash.c Timer1.c Timer4.c TypeC.c WinTimer.c
  group Main/Driver/USB
    ../../Source/Driver/USB/: hw_config.c usb_core.c usb_desc.c usb_endp.c usb_init.c usb_int.c usb_istr.c usb_mem.c usb_prop.c usb_pwr.c usb_regs.c
  group Main/GUI
    ../../Source/GUI/: HostComm.c MainPanel.c
  group StartUp
    ../../Libraries/CMSIS/Core/CM3/startup/iar/: startup_stm32f10x_cl.s
  group StdPeriphLib
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
